# Keil uVision project SPI.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: SPI +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Source
  group Source Group 1
    ./: STARTUP.A51
  group Source
    ../Source/: 24l01.c lcd.c main.c SPI.C
